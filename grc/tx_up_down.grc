options:
  parameters:
    author: jm
    copyright: szu
    generate_options: no_gui
    id: up_down_chirp
    output_language: python
    title: up_down_chirp
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: code_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: header
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: ldr
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: spreading_factor
  id: variable
  parameters:
    value: '7'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '80'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/jm/test.cfie
    type: complex
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST   20231012")
    period: '1000'
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (2 * math.pi * offset) / samp_rate
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: lora_encode_0
  id: lora_encode
  parameters:
    code_rate: code_rate
    crc: 'False'
    header: header
    low_data_rate: ldr
    spreading_factor: spreading_factor
  states: {}
- name: lora_mod_0
  id: lora_mod
  parameters:
    spreading_factor: spreading_factor
    sync_word: '18'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate/bw
    type: ccf
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: bw
    center_freq0: freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, lora_encode_0, in]
- [blocks_rotator_cc_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_socket_pdu_0, pdus, lora_encode_0, in]
- [lora_encode_0, out, lora_mod_0, in]
- [lora_mod_0, '0', blocks_rotator_cc_0, '0']
- [lora_mod_0, '0', qtgui_waterfall_sink_x_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_file_sink_0, '0']
- [pfb_arb_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
