options:
  parameters:
    author: szu-iot
    category: '[BTMA]'
    generate_options: no_gui
    id: Multi_SF_decoder_gr_lora
    output_language: python
    title: Multi_SF_decoder_gr_lora
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '3'
  states: {}
- name: crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '446000000'
  states: {}
- name: header
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: ldr
  id: variable
  parameters:
    value: 2**sf/bw > 16e-3
  states: {state: disabled}
- name: payload_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1000e3
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/szu-iot/桌面/Record/test1.cfile
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0_1_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '10'
    maxoutbuf: '100000'
    minoutbuf: '100000'
    samp_rate: 5e6
    taps: firdes.low_pass(1,5e6,5e6/(2*10)*1.2, 30e3)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 300e3
    decim: '10'
    maxoutbuf: '100000'
    minoutbuf: '100000'
    samp_rate: 5e6
    taps: firdes.low_pass(1,5e6,5e6/(2*10)*1.2, 30e3)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 900e3
    decim: '10'
    maxoutbuf: '100000'
    minoutbuf: '100000'
    samp_rate: 5e6
    taps: firdes.low_pass(1,5e6,5e6/(2*10)*1.2, 30e3)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 1200e3
    decim: '10'
    maxoutbuf: '100000'
    minoutbuf: '100000'
    samp_rate: 5e6
    taps: firdes.low_pass(1,5e6,5e6/(2*10), 30e3)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 1500e3
    decim: '10'
    maxoutbuf: '100000'
    minoutbuf: '100000'
    samp_rate: 5e6
    taps: firdes.low_pass(1,5e6,5e6/(2*10), 30e3)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 1800E3
    decim: '10'
    maxoutbuf: '100000'
    minoutbuf: '100000'
    samp_rate: 5e6
    taps: firdes.low_pass(1,5e6,5e6/(2*10), 30e3)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 2100e3
    decim: '10'
    maxoutbuf: '100000'
    minoutbuf: '100000'
    samp_rate: 5e6
    taps: firdes.low_pass(1,5e6,5e6/(2*10), 30e3)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 2400e3
    decim: '10'
    maxoutbuf: '100000'
    minoutbuf: '100000'
    samp_rate: 5e6
    taps: firdes.low_pass(1,5e6,5e6/(2*10), 30e3)
    type: ccf
  states: {}
- name: lora_decode_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '7'
  states: {}
- name: lora_decode_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '8'
  states: {}
- name: lora_decode_0_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '9'
  states: {}
- name: lora_decode_0_0_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '10'
  states: {}
- name: lora_decode_0_0_0_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '11'
  states: {}
- name: lora_decode_0_0_0_0_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'True'
    payload_len: payload_len
    spreading_factor: '12'
  states: {}
- name: lora_decode_0_1
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '7'
  states: {}
- name: lora_decode_0_1_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '8'
  states: {}
- name: lora_decode_0_1_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '9'
  states: {}
- name: lora_decode_0_1_0_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '10'
  states: {}
- name: lora_decode_0_1_0_0_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '11'
  states: {}
- name: lora_decode_0_1_0_0_0_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '12'
  states: {}
- name: lora_decode_0_1_0_0_0_0_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '12'
  states: {}
- name: lora_decode_0_1_0_0_0_0_0_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '12'
  states: {}
- name: lora_decode_0_1_0_0_0_0_0_0_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '12'
  states: {}
- name: lora_decode_0_1_0_0_0_0_0_0_0_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '12'
  states: {}
- name: lora_decode_0_1_0_0_0_0_0_0_1
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '12'
  states: {}
- name: lora_decode_0_1_0_0_0_0_0_0_1_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '12'
  states: {}
- name: lora_decode_0_1_0_0_0_0_1
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '11'
  states: {}
- name: lora_decode_0_1_0_0_0_0_1_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '11'
  states: {}
- name: lora_decode_0_1_0_0_0_0_1_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '11'
  states: {}
- name: lora_decode_0_1_0_0_0_0_1_0_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '11'
  states: {}
- name: lora_decode_0_1_0_0_0_0_1_1
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '11'
  states: {}
- name: lora_decode_0_1_0_0_0_0_1_1_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '11'
  states: {}
- name: lora_decode_0_1_0_0_0_1
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '10'
  states: {}
- name: lora_decode_0_1_0_0_0_1_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '10'
  states: {}
- name: lora_decode_0_1_0_0_0_1_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '10'
  states: {}
- name: lora_decode_0_1_0_0_0_1_0_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '10'
  states: {}
- name: lora_decode_0_1_0_0_0_1_1
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '10'
  states: {}
- name: lora_decode_0_1_0_0_0_1_1_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '10'
  states: {}
- name: lora_decode_0_1_0_0_1
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '9'
  states: {}
- name: lora_decode_0_1_0_0_1_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '9'
  states: {}
- name: lora_decode_0_1_0_0_1_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '9'
  states: {}
- name: lora_decode_0_1_0_0_1_0_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '9'
  states: {}
- name: lora_decode_0_1_0_0_1_1
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '9'
  states: {}
- name: lora_decode_0_1_0_0_1_1_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '9'
  states: {}
- name: lora_decode_0_1_0_1
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '8'
  states: {}
- name: lora_decode_0_1_0_1_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '8'
  states: {}
- name: lora_decode_0_1_0_1_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '8'
  states: {}
- name: lora_decode_0_1_0_1_0_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '8'
  states: {}
- name: lora_decode_0_1_0_1_1
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '8'
  states: {}
- name: lora_decode_0_1_0_1_1_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '8'
  states: {}
- name: lora_decode_0_1_1
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '7'
  states: {}
- name: lora_decode_0_1_1_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '7'
  states: {}
- name: lora_decode_0_1_1_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '7'
  states: {}
- name: lora_decode_0_1_1_0_0_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '7'
  states: {}
- name: lora_decode_0_1_1_1
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '7'
  states: {}
- name: lora_decode_0_1_1_1_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    spreading_factor: '7'
  states: {}
- name: lora_demod_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '7'
  states: {}
- name: lora_demod_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '8'
  states: {}
- name: lora_demod_0_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '9'
  states: {}
- name: lora_demod_0_0_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '10'
  states: {}
- name: lora_demod_0_0_0_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '11'
  states: {}
- name: lora_demod_0_0_0_0_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'True'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '12'
  states: {}
- name: lora_demod_0_1
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '7'
  states: {}
- name: lora_demod_0_1_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '8'
  states: {}
- name: lora_demod_0_1_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '11'
  states: {}
- name: lora_demod_0_1_0_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '10'
  states: {}
- name: lora_demod_0_1_0_0_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '9'
  states: {}
- name: lora_demod_0_1_0_0_0_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '9'
  states: {}
- name: lora_demod_0_1_0_0_0_0_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '9'
  states: {}
- name: lora_demod_0_1_0_0_0_0_0_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '9'
  states: {}
- name: lora_demod_0_1_0_0_0_0_0_0_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '9'
  states: {}
- name: lora_demod_0_1_0_0_0_0_0_1
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '9'
  states: {}
- name: lora_demod_0_1_0_0_0_0_0_1_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '9'
  states: {}
- name: lora_demod_0_1_0_0_0_1
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '10'
  states: {}
- name: lora_demod_0_1_0_0_0_1_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '10'
  states: {}
- name: lora_demod_0_1_0_0_0_1_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '10'
  states: {}
- name: lora_demod_0_1_0_0_0_1_0_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '10'
  states: {}
- name: lora_demod_0_1_0_0_0_1_1
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '10'
  states: {}
- name: lora_demod_0_1_0_0_0_1_1_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '10'
  states: {}
- name: lora_demod_0_1_0_0_1
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '12'
  states: {}
- name: lora_demod_0_1_0_0_1_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '12'
  states: {}
- name: lora_demod_0_1_0_0_1_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '12'
  states: {}
- name: lora_demod_0_1_0_0_1_0_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '12'
  states: {}
- name: lora_demod_0_1_0_0_1_0_0_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '12'
  states: {}
- name: lora_demod_0_1_0_0_1_0_1
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '12'
  states: {}
- name: lora_demod_0_1_0_0_1_0_1_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '12'
  states: {}
- name: lora_demod_0_1_0_0_2
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '11'
  states: {}
- name: lora_demod_0_1_0_0_2_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '11'
  states: {}
- name: lora_demod_0_1_0_0_2_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '11'
  states: {}
- name: lora_demod_0_1_0_0_2_0_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '11'
  states: {}
- name: lora_demod_0_1_0_0_2_1
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '11'
  states: {}
- name: lora_demod_0_1_0_0_2_1_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '11'
  states: {}
- name: lora_demod_0_1_0_1
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '8'
  states: {}
- name: lora_demod_0_1_0_1_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '8'
  states: {}
- name: lora_demod_0_1_0_1_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '8'
  states: {}
- name: lora_demod_0_1_0_1_0_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '8'
  states: {}
- name: lora_demod_0_1_0_1_1
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '8'
  states: {}
- name: lora_demod_0_1_0_1_1_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '8'
  states: {}
- name: lora_demod_0_1_1
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '7'
  states: {}
- name: lora_demod_0_1_1_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '7'
  states: {}
- name: lora_demod_0_1_1_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '7'
  states: {}
- name: lora_demod_0_1_1_0_0_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '7'
  states: {}
- name: lora_demod_0_1_1_1
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '7'
  states: {}
- name: lora_demod_0_1_1_1_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    dw_size: '1'
    fft_factor: '16'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '7'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '4'
    rrate: 2*250e3/5e5
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '4'
    rrate: 2*250e3/5e5
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '4'
    rrate: 2*250e3/5e5
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_0_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 2*250e3/5e5
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_0_0_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 2*250e3/5e5
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_0_0_0_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 2*250e3/5e5
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_0_0_1
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 2*250e3/5e5
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_0_0_1_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 2*250e3/5e5
    type: ccf
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: 5e6
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_addr: ''
    dev_args: '""'
    gain0: '100'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: 5e6
    sync: none
    type: fc32
  states: {}

connections:
- [freq_xlating_fir_filter_xxx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', pfb_arb_resampler_xxx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', pfb_arb_resampler_xxx_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', pfb_arb_resampler_xxx_0_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0, '0', pfb_arb_resampler_xxx_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0_0, '0', pfb_arb_resampler_xxx_0_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0_0_0, '0', pfb_arb_resampler_xxx_0_0_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_1, '0', pfb_arb_resampler_xxx_0_0_0_1_0, '0']
- [lora_decode_0, header, lora_demod_0, header]
- [lora_decode_0, out, blocks_message_debug_0, print_pdu]
- [lora_decode_0_0, header, lora_demod_0_0, header]
- [lora_decode_0_0, out, blocks_message_debug_0, print_pdu]
- [lora_decode_0_0_0, header, lora_demod_0_0_0, header]
- [lora_decode_0_0_0, out, blocks_message_debug_0, print_pdu]
- [lora_decode_0_0_0_0, header, lora_demod_0_0_0_0, header]
- [lora_decode_0_0_0_0, out, blocks_message_debug_0, print_pdu]
- [lora_decode_0_0_0_0_0, header, lora_demod_0_0_0_0_0, header]
- [lora_decode_0_0_0_0_0, out, blocks_message_debug_0, print_pdu]
- [lora_decode_0_0_0_0_0_0, header, lora_demod_0_0_0_0_0_0, header]
- [lora_decode_0_0_0_0_0_0, out, blocks_message_debug_0, print_pdu]
- [lora_decode_0_1, header, lora_demod_0_1, header]
- [lora_decode_0_1, out, blocks_message_debug_0_0, print_pdu]
- [lora_decode_0_1_0, header, lora_demod_0_1_0, header]
- [lora_decode_0_1_0, out, blocks_message_debug_0_0, print_pdu]
- [lora_decode_0_1_0_0, header, lora_demod_0_1_0_0_0_0, header]
- [lora_decode_0_1_0_0, out, blocks_message_debug_0_0, print_pdu]
- [lora_decode_0_1_0_0_0, header, lora_demod_0_1_0_0_0, header]
- [lora_decode_0_1_0_0_0, out, blocks_message_debug_0_0, print_pdu]
- [lora_decode_0_1_0_0_0_0, header, lora_demod_0_1_0_0, header]
- [lora_decode_0_1_0_0_0_0, out, blocks_message_debug_0_0, print_pdu]
- [lora_decode_0_1_0_0_0_0_0, header, lora_demod_0_1_0_0_1, header]
- [lora_decode_0_1_0_0_0_0_0, out, blocks_message_debug_0_0, print_pdu]
- [lora_decode_0_1_0_0_0_0_0_0, header, lora_demod_0_1_0_0_1_0, header]
- [lora_decode_0_1_0_0_0_0_0_0, out, blocks_message_debug_0_0_0, print_pdu]
- [lora_decode_0_1_0_0_0_0_0_0_0, header, lora_demod_0_1_0_0_1_0_0, header]
- [lora_decode_0_1_0_0_0_0_0_0_0, out, blocks_message_debug_0_0_0_0, print_pdu]
- [lora_decode_0_1_0_0_0_0_0_0_0_0, header, lora_demod_0_1_0_0_1_0_0_0, header]
- [lora_decode_0_1_0_0_0_0_0_0_0_0, out, blocks_message_debug_0_0_0_0_0, print_pdu]
- [lora_decode_0_1_0_0_0_0_0_0_0_0_0, header, lora_demod_0_1_0_0_1_0_0_0_0, header]
- [lora_decode_0_1_0_0_0_0_0_0_0_0_0, out, blocks_message_debug_0_0_0_0_0_0, print_pdu]
- [lora_decode_0_1_0_0_0_0_0_0_1, header, lora_demod_0_1_0_0_1_0_1, header]
- [lora_decode_0_1_0_0_0_0_0_0_1, out, blocks_message_debug_0_0_0_1, print_pdu]
- [lora_decode_0_1_0_0_0_0_0_0_1_0, header, lora_demod_0_1_0_0_1_0_1_0, header]
- [lora_decode_0_1_0_0_0_0_0_0_1_0, out, blocks_message_debug_0_0_0_1_0, print_pdu]
- [lora_decode_0_1_0_0_0_0_1, header, lora_demod_0_1_0_0_2, header]
- [lora_decode_0_1_0_0_0_0_1, out, blocks_message_debug_0_0_0, print_pdu]
- [lora_decode_0_1_0_0_0_0_1_0, header, lora_demod_0_1_0_0_2_0, header]
- [lora_decode_0_1_0_0_0_0_1_0, out, blocks_message_debug_0_0_0_0, print_pdu]
- [lora_decode_0_1_0_0_0_0_1_0_0, header, lora_demod_0_1_0_0_2_0_0, header]
- [lora_decode_0_1_0_0_0_0_1_0_0, out, blocks_message_debug_0_0_0_0_0, print_pdu]
- [lora_decode_0_1_0_0_0_0_1_0_0_0, header, lora_demod_0_1_0_0_2_0_0_0, header]
- [lora_decode_0_1_0_0_0_0_1_0_0_0, out, blocks_message_debug_0_0_0_0_0_0, print_pdu]
- [lora_decode_0_1_0_0_0_0_1_1, header, lora_demod_0_1_0_0_2_1, header]
- [lora_decode_0_1_0_0_0_0_1_1, out, blocks_message_debug_0_0_0_1, print_pdu]
- [lora_decode_0_1_0_0_0_0_1_1_0, header, lora_demod_0_1_0_0_2_1_0, header]
- [lora_decode_0_1_0_0_0_0_1_1_0, out, blocks_message_debug_0_0_0_1_0, print_pdu]
- [lora_decode_0_1_0_0_0_1, header, lora_demod_0_1_0_0_0_1, header]
- [lora_decode_0_1_0_0_0_1, out, blocks_message_debug_0_0_0, print_pdu]
- [lora_decode_0_1_0_0_0_1_0, header, lora_demod_0_1_0_0_0_1_0, header]
- [lora_decode_0_1_0_0_0_1_0, out, blocks_message_debug_0_0_0_0, print_pdu]
- [lora_decode_0_1_0_0_0_1_0_0, header, lora_demod_0_1_0_0_0_1_0_0, header]
- [lora_decode_0_1_0_0_0_1_0_0, out, blocks_message_debug_0_0_0_0_0, print_pdu]
- [lora_decode_0_1_0_0_0_1_0_0_0, header, lora_demod_0_1_0_0_0_1_0_0_0, header]
- [lora_decode_0_1_0_0_0_1_0_0_0, out, blocks_message_debug_0_0_0_0_0_0, print_pdu]
- [lora_decode_0_1_0_0_0_1_1, header, lora_demod_0_1_0_0_0_1_1, header]
- [lora_decode_0_1_0_0_0_1_1, out, blocks_message_debug_0_0_0_1, print_pdu]
- [lora_decode_0_1_0_0_0_1_1_0, header, lora_demod_0_1_0_0_0_1_1_0, header]
- [lora_decode_0_1_0_0_0_1_1_0, out, blocks_message_debug_0_0_0_1_0, print_pdu]
- [lora_decode_0_1_0_0_1, header, lora_demod_0_1_0_0_0_0_0, header]
- [lora_decode_0_1_0_0_1, out, blocks_message_debug_0_0_0, print_pdu]
- [lora_decode_0_1_0_0_1_0, header, lora_demod_0_1_0_0_0_0_0_0, header]
- [lora_decode_0_1_0_0_1_0, out, blocks_message_debug_0_0_0_0, print_pdu]
- [lora_decode_0_1_0_0_1_0_0, header, lora_demod_0_1_0_0_0_0_0_0_0, header]
- [lora_decode_0_1_0_0_1_0_0, out, blocks_message_debug_0_0_0_0_0, print_pdu]
- [lora_decode_0_1_0_0_1_0_0_0, header, lora_demod_0_1_0_0_0_0_0_0_0_0, header]
- [lora_decode_0_1_0_0_1_0_0_0, out, blocks_message_debug_0_0_0_0_0_0, print_pdu]
- [lora_decode_0_1_0_0_1_1, header, lora_demod_0_1_0_0_0_0_0_1, header]
- [lora_decode_0_1_0_0_1_1, out, blocks_message_debug_0_0_0_1, print_pdu]
- [lora_decode_0_1_0_0_1_1_0, header, lora_demod_0_1_0_0_0_0_0_1_0, header]
- [lora_decode_0_1_0_0_1_1_0, out, blocks_message_debug_0_0_0_1_0, print_pdu]
- [lora_decode_0_1_0_1, header, lora_demod_0_1_0_1, header]
- [lora_decode_0_1_0_1, out, blocks_message_debug_0_0_0, print_pdu]
- [lora_decode_0_1_0_1_0, header, lora_demod_0_1_0_1_0, header]
- [lora_decode_0_1_0_1_0, out, blocks_message_debug_0_0_0_0, print_pdu]
- [lora_decode_0_1_0_1_0_0, header, lora_demod_0_1_0_1_0_0, header]
- [lora_decode_0_1_0_1_0_0, out, blocks_message_debug_0_0_0_0_0, print_pdu]
- [lora_decode_0_1_0_1_0_0_0, header, lora_demod_0_1_0_1_0_0_0, header]
- [lora_decode_0_1_0_1_0_0_0, out, blocks_message_debug_0_0_0_0_0_0, print_pdu]
- [lora_decode_0_1_0_1_1, header, lora_demod_0_1_0_1_1, header]
- [lora_decode_0_1_0_1_1, out, blocks_message_debug_0_0_0_1, print_pdu]
- [lora_decode_0_1_0_1_1_0, header, lora_demod_0_1_0_1_1_0, header]
- [lora_decode_0_1_0_1_1_0, out, blocks_message_debug_0_0_0_1_0, print_pdu]
- [lora_decode_0_1_1, header, lora_demod_0_1_1, header]
- [lora_decode_0_1_1, out, blocks_message_debug_0_0_0, print_pdu]
- [lora_decode_0_1_1_0, header, lora_demod_0_1_1_0, header]
- [lora_decode_0_1_1_0, out, blocks_message_debug_0_0_0_0, print_pdu]
- [lora_decode_0_1_1_0_0, header, lora_demod_0_1_1_0_0, header]
- [lora_decode_0_1_1_0_0, out, blocks_message_debug_0_0_0_0_0, print_pdu]
- [lora_decode_0_1_1_0_0_0, header, lora_demod_0_1_1_0_0_0, header]
- [lora_decode_0_1_1_0_0_0, out, blocks_message_debug_0_0_0_0_0_0, print_pdu]
- [lora_decode_0_1_1_1, header, lora_demod_0_1_1_1, header]
- [lora_decode_0_1_1_1, out, blocks_message_debug_0_0_0_1, print_pdu]
- [lora_decode_0_1_1_1_0, header, lora_demod_0_1_1_1_0, header]
- [lora_decode_0_1_1_1_0, out, blocks_message_debug_0_0_0_1_0, print_pdu]
- [lora_demod_0, out, lora_decode_0, in]
- [lora_demod_0_0, out, lora_decode_0_0, in]
- [lora_demod_0_0_0, out, lora_decode_0_0_0, in]
- [lora_demod_0_0_0_0, out, lora_decode_0_0_0_0, in]
- [lora_demod_0_0_0_0_0, out, lora_decode_0_0_0_0_0, in]
- [lora_demod_0_0_0_0_0_0, out, lora_decode_0_0_0_0_0_0, in]
- [lora_demod_0_1, out, lora_decode_0_1, in]
- [lora_demod_0_1_0, out, lora_decode_0_1_0, in]
- [lora_demod_0_1_0_0, out, lora_decode_0_1_0_0_0_0, in]
- [lora_demod_0_1_0_0_0, out, lora_decode_0_1_0_0_0, in]
- [lora_demod_0_1_0_0_0_0, out, lora_decode_0_1_0_0, in]
- [lora_demod_0_1_0_0_0_0_0, out, lora_decode_0_1_0_0_1, in]
- [lora_demod_0_1_0_0_0_0_0_0, out, lora_decode_0_1_0_0_1_0, in]
- [lora_demod_0_1_0_0_0_0_0_0_0, out, lora_decode_0_1_0_0_1_0_0, in]
- [lora_demod_0_1_0_0_0_0_0_0_0_0, out, lora_decode_0_1_0_0_1_0_0_0, in]
- [lora_demod_0_1_0_0_0_0_0_1, out, lora_decode_0_1_0_0_1_1, in]
- [lora_demod_0_1_0_0_0_0_0_1_0, out, lora_decode_0_1_0_0_1_1_0, in]
- [lora_demod_0_1_0_0_0_1, out, lora_decode_0_1_0_0_0_1, in]
- [lora_demod_0_1_0_0_0_1_0, out, lora_decode_0_1_0_0_0_1_0, in]
- [lora_demod_0_1_0_0_0_1_0_0, out, lora_decode_0_1_0_0_0_1_0_0, in]
- [lora_demod_0_1_0_0_0_1_0_0_0, out, lora_decode_0_1_0_0_0_1_0_0_0, in]
- [lora_demod_0_1_0_0_0_1_1, out, lora_decode_0_1_0_0_0_1_1, in]
- [lora_demod_0_1_0_0_0_1_1_0, out, lora_decode_0_1_0_0_0_1_1_0, in]
- [lora_demod_0_1_0_0_1, out, lora_decode_0_1_0_0_0_0_0, in]
- [lora_demod_0_1_0_0_1_0, out, lora_decode_0_1_0_0_0_0_0_0, in]
- [lora_demod_0_1_0_0_1_0_0, out, lora_decode_0_1_0_0_0_0_0_0_0, in]
- [lora_demod_0_1_0_0_1_0_0_0, out, lora_decode_0_1_0_0_0_0_0_0_0_0, in]
- [lora_demod_0_1_0_0_1_0_0_0_0, out, lora_decode_0_1_0_0_0_0_0_0_0_0_0, in]
- [lora_demod_0_1_0_0_1_0_1, out, lora_decode_0_1_0_0_0_0_0_0_1, in]
- [lora_demod_0_1_0_0_1_0_1_0, out, lora_decode_0_1_0_0_0_0_0_0_1_0, in]
- [lora_demod_0_1_0_0_2, out, lora_decode_0_1_0_0_0_0_1, in]
- [lora_demod_0_1_0_0_2_0, out, lora_decode_0_1_0_0_0_0_1_0, in]
- [lora_demod_0_1_0_0_2_0_0, out, lora_decode_0_1_0_0_0_0_1_0_0, in]
- [lora_demod_0_1_0_0_2_0_0_0, out, lora_decode_0_1_0_0_0_0_1_0_0_0, in]
- [lora_demod_0_1_0_0_2_1, out, lora_decode_0_1_0_0_0_0_1_1, in]
- [lora_demod_0_1_0_0_2_1_0, out, lora_decode_0_1_0_0_0_0_1_1_0, in]
- [lora_demod_0_1_0_1, out, lora_decode_0_1_0_1, in]
- [lora_demod_0_1_0_1_0, out, lora_decode_0_1_0_1_0, in]
- [lora_demod_0_1_0_1_0_0, out, lora_decode_0_1_0_1_0_0, in]
- [lora_demod_0_1_0_1_0_0_0, out, lora_decode_0_1_0_1_0_0_0, in]
- [lora_demod_0_1_0_1_1, out, lora_decode_0_1_0_1_1, in]
- [lora_demod_0_1_0_1_1_0, out, lora_decode_0_1_0_1_1_0, in]
- [lora_demod_0_1_1, out, lora_decode_0_1_1, in]
- [lora_demod_0_1_1_0, out, lora_decode_0_1_1_0, in]
- [lora_demod_0_1_1_0_0, out, lora_decode_0_1_1_0_0, in]
- [lora_demod_0_1_1_0_0_0, out, lora_decode_0_1_1_0_0_0, in]
- [lora_demod_0_1_1_1, out, lora_decode_0_1_1_1, in]
- [lora_demod_0_1_1_1_0, out, lora_decode_0_1_1_1_0, in]
- [pfb_arb_resampler_xxx_0, '0', lora_demod_0, '0']
- [pfb_arb_resampler_xxx_0, '0', lora_demod_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', lora_demod_0_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', lora_demod_0_0_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', lora_demod_0_0_0_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', lora_demod_0_0_0_0_0_0, '0']
- [pfb_arb_resampler_xxx_0_0, '0', lora_demod_0_1, '0']
- [pfb_arb_resampler_xxx_0_0, '0', lora_demod_0_1_0, '0']
- [pfb_arb_resampler_xxx_0_0, '0', lora_demod_0_1_0_0, '0']
- [pfb_arb_resampler_xxx_0_0, '0', lora_demod_0_1_0_0_0, '0']
- [pfb_arb_resampler_xxx_0_0, '0', lora_demod_0_1_0_0_0_0, '0']
- [pfb_arb_resampler_xxx_0_0, '0', lora_demod_0_1_0_0_1, '0']
- [pfb_arb_resampler_xxx_0_0_0, '0', lora_demod_0_1_0_0_0_0_0, '0']
- [pfb_arb_resampler_xxx_0_0_0, '0', lora_demod_0_1_0_0_0_1, '0']
- [pfb_arb_resampler_xxx_0_0_0, '0', lora_demod_0_1_0_0_1_0, '0']
- [pfb_arb_resampler_xxx_0_0_0, '0', lora_demod_0_1_0_0_2, '0']
- [pfb_arb_resampler_xxx_0_0_0, '0', lora_demod_0_1_0_1, '0']
- [pfb_arb_resampler_xxx_0_0_0, '0', lora_demod_0_1_1, '0']
- [pfb_arb_resampler_xxx_0_0_0_0, '0', lora_demod_0_1_0_0_0_0_0_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_0, '0', lora_demod_0_1_0_0_0_1_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_0, '0', lora_demod_0_1_0_0_1_0_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_0, '0', lora_demod_0_1_0_0_2_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_0, '0', lora_demod_0_1_0_1_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_0, '0', lora_demod_0_1_1_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_0_0, '0', lora_demod_0_1_0_0_0_0_0_0_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_0_0, '0', lora_demod_0_1_0_0_0_1_0_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_0_0, '0', lora_demod_0_1_0_0_1_0_0_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_0_0, '0', lora_demod_0_1_0_0_2_0_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_0_0, '0', lora_demod_0_1_0_1_0_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_0_0, '0', lora_demod_0_1_1_0_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_0_0_0, '0', lora_demod_0_1_0_0_0_0_0_0_0_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_0_0_0, '0', lora_demod_0_1_0_0_0_1_0_0_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_0_0_0, '0', lora_demod_0_1_0_0_1_0_0_0_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_0_0_0, '0', lora_demod_0_1_0_0_2_0_0_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_0_0_0, '0', lora_demod_0_1_0_1_0_0_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_0_0_0, '0', lora_demod_0_1_1_0_0_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_1, '0', lora_demod_0_1_0_0_0_0_0_1, '0']
- [pfb_arb_resampler_xxx_0_0_0_1, '0', lora_demod_0_1_0_0_0_1_1, '0']
- [pfb_arb_resampler_xxx_0_0_0_1, '0', lora_demod_0_1_0_0_1_0_1, '0']
- [pfb_arb_resampler_xxx_0_0_0_1, '0', lora_demod_0_1_0_0_2_1, '0']
- [pfb_arb_resampler_xxx_0_0_0_1, '0', lora_demod_0_1_0_1_1, '0']
- [pfb_arb_resampler_xxx_0_0_0_1, '0', lora_demod_0_1_1_1, '0']
- [pfb_arb_resampler_xxx_0_0_0_1_0, '0', lora_demod_0_1_0_0_0_0_0_1_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_1_0, '0', lora_demod_0_1_0_0_0_1_1_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_1_0, '0', lora_demod_0_1_0_0_1_0_1_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_1_0, '0', lora_demod_0_1_0_0_2_1_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_1_0, '0', lora_demod_0_1_0_1_1_0, '0']
- [pfb_arb_resampler_xxx_0_0_0_1_0, '0', lora_demod_0_1_1_1_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0_1, '0']

metadata:
  file_format: 1
