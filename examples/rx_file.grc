options:
  parameters:
    author: jkadbear
    generate_options: no_gui
    id: rx_by_remote
    output_language: python
    title: Rx File
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: cr
  id: variable
  parameters:
    value: '3'
  states: {}
- name: crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: dw_size
  id: variable
  parameters:
    value: '2'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: header
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: ldr
  id: variable
  parameters:
    value: 2**sf/bw > 16e-3
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/jm/matlab_sig/in_iq.cfile
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jm/matlab_sig/basic_lora_packet.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: lora_decode_0
  id: lora_decode
  parameters:
    code_rate: cr
    crc: crc
    header: header
    low_data_rate: ldr
    payload_len: payload_len
    spreading_factor: sf
  states: {}
- name: lora_demod_1
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: '1'
    crc: crc
    dw_size: dw_size
    fft_factor: '1'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: ldr
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: sf
  states: {state: disabled}
- name: lora_demod_old_0
  id: lora_demod_old
  parameters:
    beta: '25.0'
    code_rate: cr
    crc: crc
    fft_factor: '10'
    fs_bw_ratio: '2'
    header: header
    low_data_rate: 'False'
    payload_len: payload_len
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: sf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bw/2+10e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 2*bw/samp_rate
    type: ccf
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', lora_demod_1, '0']
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [lora_decode_0, header, lora_demod_1, header]
- [lora_decode_0, header, lora_demod_old_0, header]
- [lora_decode_0, out, blocks_socket_pdu_0, pdus]
- [lora_demod_1, out, lora_decode_0, in]
- [lora_demod_old_0, out, lora_decode_0, in]
- [low_pass_filter_0, '0', pfb_arb_resampler_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_file_sink_0, '0']
- [pfb_arb_resampler_xxx_0, '0', lora_demod_1, '0']
- [pfb_arb_resampler_xxx_0, '0', lora_demod_old_0, '0']
- [pfb_arb_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [pfb_arb_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
